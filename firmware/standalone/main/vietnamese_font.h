#pragma once

#include <array>
#include <cstddef>
#include <cstdint>

namespace chatai::display {

struct Glyph8x12 {
    uint32_t codepoint;
    uint8_t rows[12];
};

struct UnicodeComposition {
    uint32_t base;
    uint32_t mark;
    uint32_t composed;
};

// Noto Sans Regular (SIL Open Font License 1.1), rasterized at 8 px.
// Printable ASCII plus the complete 148-character Vietnamese alphabet.
inline constexpr char kGlyphDataBase64[] =
    "ACAAAAAAAAAAAAAAAAAAIQAACAgICAgACAAAAAAiAAAYGAAAAAAAAAAAACMAABgYfCh8KDAAAAAAJAAACBwoGAwMOAAAAAAlAAAk"
    "VFheNhYmAAAAACYAADAoKBA0TD4AAAAAJwAAEBAAAAAAAAAAAAAoAAAICBAQEBAICAAAACkAABAICAgICAgQAAAAKgAACDwIFAAA"
    "AAAAAAArAAAAAAg8CAgAAAAAACwAAAAAAAAACBAAAAAALQAAAAAAABgAAAAAAAAuAAAAAAAAAAAIAAAAAC8AAAQECAgIEBAAAAAA"
    "MAAAGCQkJCQkGAAAAAAxAAAIGAgICAgIAAAAADIAADgEBAQIEDwAAAAAMwAAPAQEGAQEPAAAAAA0AAAEDBQUJDwEAAAAADUAABwQ"
    "EBgEBDwAAAAANgAADBAgPCQkHAAAAAA3AAA8BAQICAgQAAAAADgAABwkFBgkJBwAAAAAOQAAGCQkJBwEGAAAAAA6AAAAAAgAAAAI"
    "AAAAADsAAAAACAAAABAQAAAAPAAAAAAEGDAMAAAAAAA9AAAAADwAPAAAAAAAAD4AAAAAMAgMMAAAAAAAPwAAOAgICBAAEAAAAABA"
    "AAA4RFqqqrRAOAAAAEEAABAQKCg4REQAAAAAQgAAOCQkOCQkOAAAAABDAAAcIEBAQCAcAAAAAEQAADgkJCQkJDgAAAAARQAAHBAQ"
    "HBAQHAAAAABGAAAcEBAcEBAQAAAAAEcAABwgQExEJBwAAAAASAAAJCQkPCQkJAAAAABJAAAYCAgICAgYAAAAAEoAABAQEBAQEBAw"
    "AAAASwAAEhQYGBgUEgAAAABMAAAQEBAQEBAcAAAAAE0AAEREbGxsVFQAAAAATgAAJDQ0LCwkJAAAAABPAAAcJEJCQiQcAAAAAFAA"
    "ABwUFBQcEBAAAAAAUQAAHCRCQkIkHAQAAABSAAAcEhQcFBQSAAAAAFMAABwgEBgEBDgAAAAAVAAAPAgICAgICAAAAABVAAAkJCQk"
    "JCQ4AAAAAFYAACIkFBQUCAgAAAAAVwAAkpKaamxkRAAAAABYAAAmFBgIGBQmAAAAAFkAACYUGAgICAgAAAAAWgAAPAQICBAQPAAA"
    "AABbAAAICAgICAgICAAAAFwAABAQCAgIBAQAAAAAXQAAGAgICAgICBgAAABeAAAACBgUJAAAAAAAAF8AAAAAAAAAAAAAeAAAYAAQ"
    "CAAAAAAAAAAAAABhAAAAABwEHCQcAAAAAGIAABAQHBQUFBwAAAAAYwAAAAAcICAgHAAAAABkAAAEBBwkJCQcAAAAAGUAAAAAHCQ8"
    "IBwAAAAAZgAADAgcCAgICAAAAABnAAAAABwkJCQcBBwAAGgAABAQHBQUFBQAAAAAaQAACAAICAgICAAAAABqAAAgACAgICAgICAA"
    "AGsAABAQFBgYGBQAAAAAbAAACAgICAgICAAAAABtAAAAAH5SUlJSAAAAAG4AAAAAHBQUFBQAAAAAbwAAAAAcJCQkHAAAAABwAAAA"
    "ABwUFBQcEBAAAHEAAAAAHCQkJBwEBAAAcgAAAAAYEBAQEAAAAABzAAAAABggGAg4AAAAAHQAAAAIHAgICAwAAAAAdQAAAAAUFBQU"
    "HAAAAAB2AAAAACQkGBgYAAAAAHcAAAAASlo6JCQAAAAAeAAAAAAkGAgYJAAAAAB5AAAAACQkGBgIEDAAAHoAAAAAOAgQEDgAAAAA"
    "ewAACBAQECAQEAgAAAB8AAAICAgICAgICAgAAH0AADAQEBAIEBAwAAAAfgAAAAAAFCwAAAAAAADAIBAQECgoOEREAAAAAMEIEBAQ"
    "KCg4REQAAAAAwhAoEBAoKDhERAAAAADDAAA4ECgoOEREAAAAAMgQCBwQEBwQEBwAAAAAyQQIHBAQHBAQHAAAAADKCBQcEBAcEBAc"
    "AAAAAMwQCBgICAgICBgAAAAAzQQIGAgICAgIGAAAAADSEAgcJEJCQiQcAAAAANMIEBwkQkJCJBwAAAAA1BAoHCRCQkIkHAAAAADV"
    "AAA8JEJCQiQcAAAAANkQCCQkJCQkJDgAAAAA2ggQJCQkJCQkOAAAAADdCBAmFBgICAgIAAAAAOAAEAgAHAQcJBwAAAAA4QAIEAAc"
    "BBwkHAAAAADiAAgUABwEHCQcAAAAAOMAAAA4HAQcJBwAAAAA6AAQCAAcJDwgHAAAAADpAAgQABwkPCAcAAAAAOoACBQAHCQ8IBwA"
    "AAAA7AAQCAAICAgICAAAAADtAAgQAAgICAgIAAAAAPIAEAgAHCQkJBwAAAAA8wAECAAcJCQkHAAAAAD0AAgUABwkJCQcAAAAAPUA"
    "AAAcHCQkJBwAAAAA+QAQCAAUFBQUHAAAAAD6AAQIABQUFBQcAAAAAP0ACBAAJCQYGAgQMAABAgA4ECgoOEREAAAAAAEDAAAcHAQc"
    "JBwAAAAAARAAADgkJHQkJDgAAAABEQAABA4cJCQkHAAAAAEoAAAcCAgICAgYAAAAASkAAAA4CAgICAgAAAABaAAAPCQkJCQkOAAA"
    "AAFpAAAAHBQUFBQcAAAAAaAAAB4iQkJCJBwAAAABoQAAAAIeJCIkHAAAAAGvAAAlJiQkJCQ4AAAAAbAAAAACLCgoKDgAAAAeoAAA"
    "EBAoKDhERAAQAB6hAAAAABwEHCQcAAgAHqIQEBAQKCg4REQAAAAeowAICAgcBBwkHAAAAB6kHCgQECgoOEREAAAAHqUABBgAHAQc"
    "JBwAAAAepnAoEBAoKDhERAAAAB6nACAYABwEHCQcAAAAHqgYKBAQKCg4REQAAAAeqQAEDBAcBBwkHAAAAB6qKDgQECgoOEREAAAA"
    "HqsAHAgUHAQcJBwAAAAerBAoEBAoKDhERAAQAB6tAAgUABwEHCQcAAgAHq4QOBAQKCg4REQAAAAerwAIFBgcBBwkHAAAAB6wEDgQ"
    "ECgoOEREAAAAHrEAEBQYHAQcJBwAAAAeshA4EBAoKDhERAAAAB6zAAgYGBwEHCQcAAAAHrQoEBAQKCg4REQAAAAetQAcFBgcBBwk"
    "HAAAAB62ADgQKCg4REQAEAAAHrcAABwcBBwkHAAIAAAeuAAAHBAQHBAQHAAIAB65AAAAABwkPCAcAAgAHroICBwQEBwQEBwAAAAe"
    "uwAICAgcJDwgHAAAAB68AAAcEBAcEBAcAAAAHr0AAAA4HCQ8IBwAAAAevgwUHBAQHBAQHAAAAB6/AAQIFBwkPCAcAAAAHsAoFBwQ"
    "EBwQEBwAAAAewQAgCBQcJDwgHAAAAB7CDBQcEBAcEBAcAAAAHsMABAwQHCQ8IBwAAAAexBgYHBAQHBAQHAAAAB7FABwIFBwkPCAc"
    "AAAAHsYIFBwQEBwQEBwACAAexwAIFAAcJDwgHAAIAB7ICAgYCAgICAgYAAAAHskAGAgICAgICAgAAAAeygAAGAgICAgIGAAIAB7L"
    "AAAQABAQEBAQABAAHswAABwkQkJCJBwACAAezQAAAAAcJCQkHAAIAB7OCAgcJEJCQiQcAAAAHs8ACAgIHCQkJBwAAAAe0AwYHCRC"
    "QkIkHAAAAB7RAAIMFBwkIiQcAAAAHtIoGBwkQkJCJBwAAAAe0wAgGBQcJCQkHAAAAB7UBBgcJEJCQiQcAAAAHtUABAwQHCQkJBwA"
    "AAAe1hgYHCRCQkIkHAAAAB7XABwIFBwkJCQcAAAAHtgQKBwkQkJCJBwACAAe2QAIFAAcJCQkHAAIAB7aCBAeIkJCQiQcAAAAHtsA"
    "BAgCHiQiJBwAAAAe3BAIHiJCQkIkHAAAAB7dABAIAh4kIiQcAAAAHt4ICB4iQkJCJBwAAAAe3wAICAoeJCIkHAAAAB7gAAA+IkJC"
    "QiQcAAAAHuEAAAAeHiQiJBwAAAAe4gAAHiJCQkIkHAAIAB7jAAAAAh4kIiQcAAgAHuQAACQkJCQkJDgAEAAe5QAAAAAUFBQUHAAI"
    "AB7mGBAkJCQkJCQ4AAAAHucACAgIFBQUFBwAAAAe6AgQJSYkJCQkOAAAAB7pAAgQAiwoKCg4AAAAHuoQCCUmJCQkJDgAAAAe6wAg"
    "EAIsKCgoOAAAAB7sGAglJiQkJCQ4AAAAHu0AEBASLCgoKDgAAAAe7gAAPSYkJCQkOAAAAB7vAAAAOiwoKCg4AAAAHvAAACUmJCQk"
    "JDgAEAAe8QAAAAIsKCgoOAAQAB7yEAgmFBgICAgIAAAAHvMAEAgAJCQYGAgQMAAe9AAAJhQYCAgICAAIAB71AAAAACQkGBgIEDgA"
    "HvYICCYUGAgICAgAAAAe9wAYCBAkJBgYCBAwAB74AAA+FBgICAgIAAAAHvkAAAA4JCQYGAgQMAA=";

inline constexpr char kCompositionDataBase64[] =
    "AEEDAADAAEEDAQDBAEEDAgDCAEEDAwDDAEEDBgECAEEDCR6iAEEDIx6gAEUDAADIAEUDAQDJAEUDAgDKAEUDAx68AEUDCR66AEUD"
    "Ix64AEkDAADMAEkDAQDNAEkDAwEoAEkDCR7IAEkDIx7KAE8DAADSAE8DAQDTAE8DAgDUAE8DAwDVAE8DCR7OAE8DGwGgAE8DIx7M"
    "AFUDAADZAFUDAQDaAFUDAwFoAFUDCR7mAFUDGwGvAFUDIx7kAFkDAB7yAFkDAQDdAFkDAx74AFkDCR72AFkDIx70AGEDAADgAGED"
    "AQDhAGEDAgDiAGEDAwDjAGEDBgEDAGEDCR6jAGEDIx6hAGUDAADoAGUDAQDpAGUDAgDqAGUDAx69AGUDCR67AGUDIx65AGkDAADs"
    "AGkDAQDtAGkDAwEpAGkDCR7JAGkDIx7LAG8DAADyAG8DAQDzAG8DAgD0AG8DAwD1AG8DCR7PAG8DGwGhAG8DIx7NAHUDAAD5AHUD"
    "AQD6AHUDAwFpAHUDCR7nAHUDGwGwAHUDIx7lAHkDAB7zAHkDAQD9AHkDAx75AHkDCR73AHkDIx71AMIDAB6mAMIDAR6kAMIDAx6q"
    "AMIDCR6oAMoDAB7AAMoDAR6+AMoDAx7EAMoDCR7CANQDAB7SANQDAR7QANQDAx7WANQDCR7UAOIDAB6nAOIDAR6lAOIDAx6rAOID"
    "CR6pAOoDAB7BAOoDAR6/AOoDAx7FAOoDCR7DAPQDAB7TAPQDAR7RAPQDAx7XAPQDCR7VAQIDAB6wAQIDAR6uAQIDAx60AQIDCR6y"
    "AQMDAB6xAQMDAR6vAQMDAx61AQMDCR6zAaADAB7cAaADAR7aAaADAx7gAaADCR7eAaADIx7iAaEDAB7dAaEDAR7bAaEDAx7hAaED"
    "CR7fAaEDIx7jAa8DAB7qAa8DAR7oAa8DAx7uAa8DCR7sAa8DIx7wAbADAB7rAbADAR7pAbADAx7vAbADCR7tAbADIx7xHqADAh6s"
    "HqADBh62HqEDAh6tHqEDBh63HrgDAh7GHrkDAh7HHswDAh7YHs0DAh7Z";

constexpr uint32_t Base64Value(char c) {
    return c >= 'A' && c <= 'Z' ? c - 'A' :
           c >= 'a' && c <= 'z' ? c - 'a' + 26 :
           c >= '0' && c <= '9' ? c - '0' + 52 :
           c == '+' ? 62 : c == '/' ? 63 : 0;
}

constexpr uint8_t DecodeBase64Byte(const char* data, size_t index) {
    const size_t group = (index / 3) * 4;
    const size_t offset = index % 3;
    const uint32_t packed =
        (Base64Value(data[group]) << 18) |
        (Base64Value(data[group + 1]) << 12) |
        (Base64Value(data[group + 2]) << 6) |
        Base64Value(data[group + 3]);
    return static_cast<uint8_t>((packed >> (16 - offset * 8)) & 0xFF);
}

constexpr auto BuildVietnameseFont() {
    std::array<Glyph8x12, 229> result{};
    for (size_t i = 0; i < result.size(); ++i) {
        const size_t offset = i * 14;
        result[i].codepoint =
            (static_cast<uint32_t>(DecodeBase64Byte(kGlyphDataBase64, offset)) << 8) |
            DecodeBase64Byte(kGlyphDataBase64, offset + 1);
        for (size_t row = 0; row < 12; ++row) {
            result[i].rows[row] = DecodeBase64Byte(kGlyphDataBase64, offset + 2 + row);
        }
    }
    return result;
}

constexpr auto BuildVietnameseCompositions() {
    std::array<UnicodeComposition, 132> result{};
    for (size_t i = 0; i < result.size(); ++i) {
        const size_t offset = i * 6;
        result[i] = {
            (static_cast<uint32_t>(DecodeBase64Byte(kCompositionDataBase64, offset)) << 8) |
                DecodeBase64Byte(kCompositionDataBase64, offset + 1),
            (static_cast<uint32_t>(DecodeBase64Byte(kCompositionDataBase64, offset + 2)) << 8) |
                DecodeBase64Byte(kCompositionDataBase64, offset + 3),
            (static_cast<uint32_t>(DecodeBase64Byte(kCompositionDataBase64, offset + 4)) << 8) |
                DecodeBase64Byte(kCompositionDataBase64, offset + 5)
        };
    }
    return result;
}

inline constexpr auto kVietnameseFont = BuildVietnameseFont();
inline constexpr auto kVietnameseCompositions = BuildVietnameseCompositions();

}  // namespace chatai::display
